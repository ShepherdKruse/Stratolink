#include "crypto_aes128.h"

#include <string.h>

static const uint8_t SBOX[256] = {
    0x63,0x7c,0x77,0x7b,0xf2,0x6b,0x6f,0xc5,0x30,0x01,0x67,0x2b,0xfe,0xd7,0xab,0x76,
    0xca,0x82,0xc9,0x7d,0xfa,0x59,0x47,0xf0,0xad,0xd4,0xa2,0xaf,0x9c,0xa4,0x72,0xc0,
    0xb7,0xfd,0x93,0x26,0x36,0x3f,0xf7,0xcc,0x34,0xa5,0xe5,0xf1,0x71,0xd8,0x31,0x15,
    0x04,0xc7,0x23,0xc3,0x18,0x96,0x05,0x9a,0x07,0x12,0x80,0xe2,0xeb,0x27,0xb2,0x75,
    0x09,0x83,0x2c,0x1a,0x1b,0x6e,0x5a,0xa0,0x52,0x3b,0xd6,0xb3,0x29,0xe3,0x2f,0x84,
    0x53,0xd1,0x00,0xed,0x20,0xfc,0xb1,0x5b,0x6a,0xcb,0xbe,0x39,0x4a,0x4c,0x58,0xcf,
    0xd0,0xef,0xaa,0xfb,0x43,0x4d,0x33,0x85,0x45,0xf9,0x02,0x7f,0x50,0x3c,0x9f,0xa8,
    0x51,0xa3,0x40,0x8f,0x92,0x9d,0x38,0xf5,0xbc,0xb6,0xda,0x21,0x10,0xff,0xf3,0xd2,
    0xcd,0x0c,0x13,0xec,0x5f,0x97,0x44,0x17,0xc4,0xa7,0x7e,0x3d,0x64,0x5d,0x19,0x73,
    0x60,0x81,0x4f,0xdc,0x22,0x2a,0x90,0x88,0x46,0xee,0xb8,0x14,0xde,0x5e,0x0b,0xdb,
    0xe0,0x32,0x3a,0x0a,0x49,0x06,0x24,0x5c,0xc2,0xd3,0xac,0x62,0x91,0x95,0xe4,0x79,
    0xe7,0xc8,0x37,0x6d,0x8d,0xd5,0x4e,0xa9,0x6c,0x56,0xf4,0xea,0x65,0x7a,0xae,0x08,
    0xba,0x78,0x25,0x2e,0x1c,0xa6,0xb4,0xc6,0xe8,0xdd,0x74,0x1f,0x4b,0xbd,0x8b,0x8a,
    0x70,0x3e,0xb5,0x66,0x48,0x03,0xf6,0x0e,0x61,0x35,0x57,0xb9,0x86,0xc1,0x1d,0x9e,
    0xe1,0xf8,0x98,0x11,0x69,0xd9,0x8e,0x94,0x9b,0x1e,0x87,0xe9,0xce,0x55,0x28,0xdf,
    0x8c,0xa1,0x89,0x0d,0xbf,0xe6,0x42,0x68,0x41,0x99,0x2d,0x0f,0xb0,0x54,0xbb,0x16
};
static const uint8_t RCON[11] =
    {0x00,0x01,0x02,0x04,0x08,0x10,0x20,0x40,0x80,0x1b,0x36};

static void key_expand(const uint8_t key[16], uint8_t round_key[176]) {
    memcpy(round_key, key, 16);
    for (int i = 4; i < 44; ++i) {
        uint8_t t[4];
        memcpy(t, &round_key[(i - 1) * 4], 4);
        if (i % 4 == 0) {
            uint8_t first = t[0];
            t[0] = SBOX[t[1]] ^ RCON[i / 4];
            t[1] = SBOX[t[2]];
            t[2] = SBOX[t[3]];
            t[3] = SBOX[first];
        }
        for (int j = 0; j < 4; ++j) {
            round_key[i * 4 + j] = round_key[(i - 4) * 4 + j] ^ t[j];
        }
    }
}

static uint8_t xtime(uint8_t value) {
    return (uint8_t)((value << 1) ^ ((value >> 7) * 0x1b));
}

void aes128_encrypt_block(const uint8_t key[16], const uint8_t input[16],
                          uint8_t output[16]) {
    uint8_t round_key[176], state[16];
    key_expand(key, round_key);
    for (int i = 0; i < 16; ++i) state[i] = input[i] ^ round_key[i];
    for (int round = 1; round <= 10; ++round) {
        uint8_t substituted[16];
        for (int i = 0; i < 16; ++i) substituted[i] = SBOX[state[i]];
        state[0]=substituted[0]; state[1]=substituted[5];
        state[2]=substituted[10]; state[3]=substituted[15];
        state[4]=substituted[4]; state[5]=substituted[9];
        state[6]=substituted[14]; state[7]=substituted[3];
        state[8]=substituted[8]; state[9]=substituted[13];
        state[10]=substituted[2]; state[11]=substituted[7];
        state[12]=substituted[12]; state[13]=substituted[1];
        state[14]=substituted[6]; state[15]=substituted[11];
        if (round < 10) {
            for (int i = 0; i < 4; ++i) {
                uint8_t a=state[i*4], b=state[i*4+1];
                uint8_t c=state[i*4+2], d=state[i*4+3];
                state[i*4] = xtime(a)^xtime(b)^b^c^d;
                state[i*4+1] = a^xtime(b)^xtime(c)^c^d;
                state[i*4+2] = a^b^xtime(c)^xtime(d)^d;
                state[i*4+3] = xtime(a)^a^b^c^xtime(d);
            }
        }
        for (int i = 0; i < 16; ++i) {
            state[i] ^= round_key[round * 16 + i];
        }
    }
    memcpy(output, state, 16);
}

static void shift_left_128(const uint8_t input[16], uint8_t output[16]) {
    for (int i = 0; i < 15; ++i) {
        output[i] = (uint8_t)((input[i] << 1) | (input[i + 1] >> 7));
    }
    output[15] = (uint8_t)(input[15] << 1);
}

bool aes128_cmac(const uint8_t key[16], const uint8_t* message, size_t length,
                 uint8_t mac[16]) {
    /* The largest project input is LoRaWAN B0 plus a 255-byte message. Keep
     * this primitive explicitly bounded: otherwise an overflow-sized corrupt
     * length can wrap `(length + 15)`, collapse the block count, and turn the
     * final 16-byte staging copy into an unbounded copy. */
    if (!key || !mac || (length && !message) ||
        length > AES128_CMAC_MAX_BYTES) return false;

    uint8_t l[16] = {}, k1[16], k2[16];
    aes128_encrypt_block(key, l, l);
    shift_left_128(l, k1);
    if (l[0] & 0x80) k1[15] ^= 0x87;
    shift_left_128(k1, k2);
    if (k1[0] & 0x80) k2[15] ^= 0x87;

    size_t blocks = length / 16u + (length % 16u != 0u ? 1u : 0u);
    if (!blocks) blocks = 1;
    bool complete = length > 0 && length % 16 == 0;
    uint8_t x[16] = {};
    for (size_t block = 0; block + 1 < blocks; ++block) {
        for (size_t j = 0; j < 16; ++j) x[j] ^= message[block * 16 + j];
        aes128_encrypt_block(key, x, x);
    }

    uint8_t last[16] = {};
    size_t last_length = length - (blocks - 1) * 16;
    if (last_length) {
        memcpy(last, message + (blocks - 1) * 16, last_length);
    }
    if (complete) {
        for (int j = 0; j < 16; ++j) last[j] ^= k1[j];
    } else {
        last[last_length] = 0x80;
        for (int j = 0; j < 16; ++j) last[j] ^= k2[j];
    }
    for (int j = 0; j < 16; ++j) x[j] ^= last[j];
    aes128_encrypt_block(key, x, mac);
    return true;
}
